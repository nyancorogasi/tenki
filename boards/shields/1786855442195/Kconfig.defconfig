## boards/shields/1786855442195/Kconfig.defconfig
```kconfig
if SHIELD_1786855442195

config ZMK_KEYBOARD_NAME
    default "1786855442195"

endif
```
